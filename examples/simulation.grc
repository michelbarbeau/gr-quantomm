<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>Message_Debug_Out_Plain_Text</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>5</value></param>
<param><key>num_samps</key><value>10</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>0.1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>quantomm_channel_ii</key>
<param><key>id</key><value>quantomm_channel_ii_0</value></param>
</block>
<block>
<key>quantomm_channel_ii</key>
<param><key>id</key><value>quantomm_channel_ii_1</value></param>
</block>
<block>
<key>quantomm_decoder</key>
<param><key>id</key><value>quantomm_decoder_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>quantomm_encoder</key>
<param><key>id</key><value>quantomm_encoder_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>quantomm_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quantomm_channel_ii_0</source_block_id><sink_block_id>quantomm_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quantomm_channel_ii_1</source_block_id><sink_block_id>quantomm_decoder_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>quantomm_decoder_0</source_block_id><sink_block_id>quantomm_encoder_0</sink_block_id><source_key>feedback</source_key><sink_key>feedback</sink_key></connection>
<connection><source_block_id>quantomm_decoder_0</source_block_id><sink_block_id>Message_Debug_Out_Plain_Text</sink_block_id><source_key>plaintext</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>quantomm_encoder_0</source_block_id><sink_block_id>quantomm_channel_ii_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quantomm_encoder_0</source_block_id><sink_block_id>quantomm_channel_ii_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>quantomm_encoder_0</source_block_id><sink_block_id>quantomm_decoder_0</sink_block_id><source_key>ciphertext</source_key><sink_key>ciphertext</sink_key></connection>
</flow_graph>
